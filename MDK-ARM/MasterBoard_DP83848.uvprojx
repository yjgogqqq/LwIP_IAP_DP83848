# Keil uVision project MasterBoard_DP83848.uvprojx, settings and files
target MasterBoard_DP83848 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MasterBoard_DP83848
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_PRINTF
  c include: ../Core/Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include;..\Motus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Motus
    ../Motus/: tftpserver.c tftputils.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_can.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sd.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal.c
  group Application/User
    ../Core/Src/: iwdg.c sdio.c tim.c ethernetif.c main.c fatfs.c wwdg.c can.c bsp_driver_sd.c dma.c stm32f4xx_it.c gpio.c usart.c sd_diskio.c stm32f4xx_hal_msp.c lwip.c flash_if.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: multilink.c eui64.c fsm.c demand.c chap_ms.c auth.c ccp.c chap-new.c mppe.c pppoe.c pppol2tp.c ipv6cp.c ecp.c ppp.c pppapi.c utils.c vj.c pppcrypt.c pppos.c ipcp.c upap.c lcp.c eap.c chap-md5.c magic.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: nd6.c ip6_frag.c mld6.c icmp6.c ethip6.c ip6_addr.c inet6.c dhcp6.c ip6.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c dns.c tcp_out.c ip.c udp.c mem.c timeouts.c sys.c def.c init.c memp.c stats.c inet_chksum.c raw.c pbuf.c netif.c tcp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: dhcp.c ip4_addr.c icmp.c ip4_frag.c autoip.c igmp.c etharp.c ip4.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/apps/tftp/: tftp_server.c
    ../Middlewares/Third_Party/LwIP/src/api/: sockets.c netbuf.c err.c netdb.c tcpip.c api_msg.c api_lib.c netifapi.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 5.0.0
